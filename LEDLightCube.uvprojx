# Keil uVision project LEDLightCube.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Enlight_LEDs +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS;.\Libraries\src;.\System\delay;.\System\sys;.\System\usart;.\User;.\Libraries\inc;.\Hardware\HT1632C;.\User\GPIO;.\User\USART1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ./Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_dbgmcu.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
  group User
    ./User/: main.c stm32f10x_it.c stm32f10x_conf.h
    ./User/USART1/: usart1.c usart1.h
    ./User/GPIO/: gpio.c gpio.h
  group Hardware
    ./Hardware/HT1632C/: HT1632C.c HT1632C.h
  group Docs
    ./Docs/: readme.txt
